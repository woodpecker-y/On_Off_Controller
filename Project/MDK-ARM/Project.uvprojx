# Keil uVision project Project.uvprojx, settings and files
target STM32F103CB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tongDuanKongZhiQi_0109 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./../../Bin/App.bin ./App/Obj/App.axf
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,DEBUG,HAVE_COM,HAVE_RTC,HAVE_EXTI,HAVE_WDG,HAVE_RF,HAVE_MOTOR,HAVE_HT1621,HAVE_FLASH,HAVE_ENCRYPT,HAVE_FILESYSTEM,HAVE_FLASH_EXT,HAVE_FLASH,HAVE_LED,HAVE_LCD,HAVE_ADC,HAVE_SYSTIMER,HAVE_DBG,HAVE_PVD
  c include: ..\..\User\inc;..\..\HAL\inc;..\..\Board;..\..\Lib\include\BSP;..\..\Lib\include\Libraries;..\..\Lib\include\HAL;..\..\Lib\include;..\..\Lib\include\Utili;..\..\Lib\include\Module\DevMgr;..\..\Lib\include\Module\FileSystem;..\..\Lib\include\Module\Font;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM3;..\..\User\TimBase;..\..\Task\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Board
    ../../Board/: board.c board.h
  group Lib
    ../../Lib/: ADF.lib
  group User
    ../../User/src/: main.c sysparams.c stm32f10x_it.c display.c fy_protocol.c bsp_TiMbase.c valve_deal.c recv_data_deal.c error.c
    ../../User/inc/: FreeRTOSConfig.h sysparams.h
    ../../Lib/include/Utili/: utili.h
  group AppTask
    ../../Task/src/: app_task.c vTask_Com_Rf_Valve.c vTask_Power_Display_Temp_Runled.c vTask_Calculate.c vTaskRunTimeStats.c
  group FreeRTOS/Source
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../../FreeRTOS/port/RVDS/ARM_CM3/: port.c
    ../../FreeRTOS/port/MemMang/: heap_4.c
  group Doc
    ../../Docs/: README.txt protocol_example.txt 功能描述.txt
target tongDuanKongZhiQi (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: 一体阀通断控制器（不带温度探头） +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target wenKongYiTiHua (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: tongDuanKongZhiQi_0109 +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
